# Keil uVision project LoRaMac_classA.uvprojx, settings and files
target RegionUS915 (6120000::V6.12::.\ARMCLANG)
  device: M252KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: IRAM(0x20000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M23") CLOCK(12000000)
  output: LoRaMac_classA
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: ACTIVE_REGION=LORAMAC_REGION_US915 REGION_US915 SX1276MB1MAS USE_FULL_ASSERT
  c include: ..\..\..\..\..\boards\mcu\M251\Include;..\..\..\..\..\boards\NuMaker-IOT-M252;..\..\..\..\..\..\..\BSP\M251BSP\Library\CMSIS\Include;..\..\..\..\..\..\..\BSP\M251BSP\Library;..\..\..\..\..\..\..\BSP\M251BSP\Library\Device\Nuvoton\M251\Include;..\..\..\..\..\..\..\LoRaMac-node\src\boards;..\..\..\..\..\..\..\LoRaMac-node\src\mac;..\..\..\..\..\..\..\LoRaMac-node\src\system;..\..\..\..\..\..\..\LoRaMac-node\src\radio;..\..\..\..\..\..\..\LoRaMac-node\src\apps\LoRaMac\common;..\..\..\..\..\..\..\LoRaMac-node\src\peripherals\soft-se
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --map --first='startup_M251.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../../boards/mcu/M251/Device/Nuvoton/M251/Source/: system_M251.c
    ../../../../../boards/mcu/M251/Device/Nuvoton/M251/Source/ARM/: startup_M251.s
  group User
    ../: main.c cJSON.c
  group BSPLibrary
    ../../../../../../../BSP/M251BSP/Library/StdDriver/src/: retarget.c sys.c clk.c uart.c gpio.c spi.c rtc.c fmc.c i2c.c
  group LoRaMac_boards
    ../../../../../boards/NuMaker-IOT-M252/: board.c gpio-board.c spi-board.c lpm-board.c rtc-board.c eeprom-board.c sx1276mb1mas-board.c i2c-board.c uart-board.c
    ../../../../../../../LoRaMac-node/src/boards/mcu/: utilities.c
  group LoRaMac_system
    ../../../../../../../LoRaMac-node/src/system/: gpio.c nvmm.c eeprom.c timer.c systime.c delay.c fifo.c uart.c
  group LoRaMac_mac
    ../../../../../../../LoRaMac-node/src/mac/: LoRaMac.c LoRaMacAdr.c LoRaMacClassB.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacParser.c LoRaMacSerializer.c
    ../../../../../../../LoRaMac-node/src/mac/region/: Region.c RegionCommon.c RegionEU868.c RegionCN470.c RegionUS915.c RegionAU915.c
  group LoRaMac_apps_LoRaMac_common
    ../../../../../../../LoRaMac-node/src/apps/LoRaMac/common/: NvmCtxMgmt.c
  group LoRaMac_radio_sx1276
    ../../../../../../../LoRaMac-node/src/radio/sx1276/: sx1276.c
  group LoRaMac_peripherals_soft-se
    ../../../../../../../LoRaMac-node/src/peripherals/soft-se/: soft-se.c aes.c cmac.c soft-se-hal.c
target RegionAU915 (6120000::V6.12::.\ARMCLANG)
  device: M252KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: as above
  output: LoRaMac_classA
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: ACTIVE_REGION=LORAMAC_REGION_AU915 REGION_AU915 SX1276MB1MAS USE_FULL_ASSERT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: as above
target RegionEU868 (6120000::V6.12::.\ARMCLANG)
  device: M252KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: as above
  output: LoRaMac_classA
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: ACTIVE_REGION=LORAMAC_REGION_EU868 REGION_EU868 SX1276MB1MAS USE_FULL_ASSERT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: as above
target RegionCN470 (6120000::V6.12::.\ARMCLANG)
  device: M252KG6AE Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.10
  cpu: as above
  output: LoRaMac_classA
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: ACTIVE_REGION=LORAMAC_REGION_CN470 REGION_CN470 SX1276MB1MAS USE_FULL_ASSERT
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: as above
software components: CMSIS:CORE 5.2.0
